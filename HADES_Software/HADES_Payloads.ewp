# IAR project HADES_Payloads.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ewarm; PART_TM4C123GH6PM; TARGET_IS_TM4C123_RB1; UART_BUFFERED
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..\..\..
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..; ..\..\..\..; $PROJ_DIR$
  OBJCOPY.OOCOutputFile: HADES_Payloads.bin
  ILINK.IlinkOutputFile: HADES.out
  ILINK.IlinkIcfFile: HADES.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../driverlib/ewarm/Exe/: driverlib.a
    ../sensorlib/ewarm/Exe/: sensorlib.a
  group Source
    fatfs/: ff.c
    ./: main.c microSD.c startup_ewarm.c tm4c_fatfs.c
    drivers/: rgb.c
    ../userlib/: timer.c
    ../utils/: uartstdio.c
