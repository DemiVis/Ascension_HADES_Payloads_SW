<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\..\driverlib\driverlib.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\HADES_SENSHUB_SW_TAKE2\HADES_SENSEHUB_SW_Take2.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\HADSE_SENSHUB_SW\HADES_SW.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\usblib\usblib.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\sensorlib\sensorlib.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\airmouse\airmouse.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\compdcm_mpu9150\compdcm_mpu9150.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\humidity_sht21\humidity_sht21.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\light_isl29023\light_isl29023.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\pressure_bmp180\pressure_bmp180.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\temperature_tmp006\temperature_tmp006.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All Examples</name>
      <member>
        <project>driverlib</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usblib</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>sensorlib</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>airmouse</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>compdcm_mpu9150</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>humidity_sht21</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>light_isl29023</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>pressure_bmp180</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>temperature_tmp006</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


